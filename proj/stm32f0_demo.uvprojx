# Keil uVision project stm32f0_demo.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_demo +hex
  AfterMake: fromelf --bin --output=./bin/stm32f0_demo.bin ./Objects/stm32f0_demo.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,DEBUG_MSG
  c include: ..\module;..\common;..\util;..\user;..\driver;..\lib\STM32F0xx_StdPeriph_Driver\inc;..\driver\board;..\driver\cc1101;..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../user/: main.c stm32f0xx_it.c
  group lib
    ../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group dirver
    ../driver/: systick.c usart.c eeprom.c
    ../driver/board/: hal_led.c hal_pwm.c
  group cc1101
    ../driver/cc1101/: hal_rf.c rf.c
software components: CMSIS:CORE 5.0.1, Data Exchange:JSON:Jansson 2.7.0, Device:Startup 2.2.3
