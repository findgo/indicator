# Keil uVision project indicator_stm32CubeMx.uvprojx, settings and files
target indicator_stm32CubeMx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: indicator_f0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F030x8,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0
  c include: ../Inc;       ../Drivers/STM32F0xx_HAL_Driver/Inc;       ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;       ../Drivers/CMSIS/Include;       ..\bxCommon;       ..\bxDriver;       ..\bxModule;       ..\bxModule\mo;       ..\bxLib\UGUI;       ../Core/Inc;       ..\bxLib\modbus\include;       ..\bxLib\modbus\include\rtu;       ..\bxLib\modbus\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_adc.c stm32f0xx_ll_dma.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group bxDriver
    ../bxDriver/: hal_simspi.c bxusart.c drv12864.c hal_spi.c indicator.c loop.c systick.c hmi.c bxmisc.c bxmb.c hal_adc.c
  group bxModule/mo
    ../bxModule/mo/: list.c msglink.c task.c log.c timers.c queue.c heap_4.c memalloc.c
  group bxModule
    ../bxModule/: Mserial.c port_atom.c delay.c mclock.c bxleds.c mcoils.c mkey.c mcheck.c
  group bxUgui
    ../bxLib/UGUI/: ugui.c ugui_lowdrv.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c wwdg.c stm32f0xx_it.c
  group modbus
    ../bxLib/modbus/src/: mbs.c
    ../bxLib/modbus/src/rtu/: mbsrtu.c
    ../bxLib/modbus/src/func/: mbsfuncregs.c mbsfuncother.c mbsfuncbits.c mbsfunc.c mbutils.c
  group modbus/port
    ../bxLib/modbus/port/: porttimer.c portserial.c
software components: CMSIS:CORE 4.3.0
